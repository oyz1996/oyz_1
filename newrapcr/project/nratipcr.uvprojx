# Keil uVision project nratipcr.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nratipcr +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Flash\Obj\@L.bin !L
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\device;..\lib\inc;..\project;..\startup;..\user;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\Keil;..\FreeRTOS\Source\portable\MemMang;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\module
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group lib
    ../lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ../user/: main.c stm32f4xx_it.c
  group device
    ../device/: gpio.c gpio.h gpio_in.h adc.c adc.h adc_in.h iic.c iic.h iic_in.h usart1.c usart1.h usart1_in.h usart2.c usart2.h usart2_in.h usart3.c usart3.h usart3_in.h usart6.c usart6.h usart6_in.h tim1.c tim1.h tim1_in.h tim9.c tim9.h tim9_in.h tim3.c tim3.h tim4.c tim4.h tim4_in.h exti.c exti.h tim_exti.h
    ./: tim3_in.h exti_in.h
  group FreeRtos
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group module
    ../module/: control.c control.h control_in.h resolv.c resolv.h resolv_in.h worksequ.c worksequ.h worksequ_in.h commwind.c commwind.h commwind_in.h elect.c elect.h elect_in.h inspection.c inspection.h inspection_in.h
